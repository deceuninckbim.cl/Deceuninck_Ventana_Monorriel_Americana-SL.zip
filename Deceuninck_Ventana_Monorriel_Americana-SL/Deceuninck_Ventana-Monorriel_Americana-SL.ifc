Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-12-26T11:13:58
Author: Scarlett Alday, s.aldayaranda@gmail.com
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Dec 26 11:13:58 2023 * Host: LAPTOP-VOCR0U39 * Database: C:\Users\salda\AppData\Local\Temp\792897df-17cf-4808-9be0-231cc600ccb6\2dabffe0-cc83-4a45-971e-f3c52eb51fcb\ifc * Database version: 5507 * Database creation date: Tue Dec 26 11:13:58 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Dec 26 11:13:58 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Dec 26 11:13:58 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Deceuninck_Ventana-Monorriel_Americana-SL:Deceuninck_Ventana-Monorriel_Americana-SL, Deceuninck_Ventana-Monorriel_Americana-SL:Deceuninck_Ventana-Monorriel_Americana-SL:648017
In: Level 1
Type - Classification: B2020100 Windows (Uniformat); Material: PVC, Deceuninck - 1.White/PVC, Galvanized steel, Vidrio
Type - Analytical Properties - Analytic Construction: <None>; Define Thermal Properties by: Schematic Type
Type - Construction - Wall Closure: By host
Type - Dimensions - Glass Height: 1406 mm; Glass Width: 906 mm; Height: 1500 mm; Max. Height: 1500 mm; Max. Width: 1000 mm; Rough Height: 1410 mm; Sash Fit: 34 mm; Width: 1000 mm
Type - Identity Data - Assembly Code: B2020100; Assembly Description: Windows; C-Section Model: https://deceuninckbim.cl/pdf/fichas/SL-DL322-monorriel.pdf; Glass Type: Monolitic, laminated, thermopanel; Glazing capacity: 4 a 16 mm; International Certification: ISO 9001-ISO 14001-ISO 18001 approved by TUV Rheiland; Line: SL-322; Maintenance: https://deceuninck.cl/pdf/mantencion.pdf; Manufacturer: Deceuninck; Model: Monorail; OmniClass Number: 23.30.20.00; OmniClass Title: Windows; Opening: Sliding; Panels: 1 fixed, 1 sliding; Profundidad constructiva: 60mm; Technical Area: info@deceuninckbim.cl; Type Mark: 115; Type Name: Deceuninck_Ventana-Monorriel_Americana-SL; URL: www.deceuninck.cl
Type - Materials and Finishes - Availables colours: https://deceuninckbim.cl/pdf/fichas/SL-DL322-monorriel.pdf; Frame: Deceuninck - 1.White/PVC; Handle: PVC; Reinforcement: Galvanized steel; Sash: Deceuninck - 1.White/PVC
Type - Other - Category: Windows; Altura de antepecho por defecto: 800 mm; Family Name: Deceuninck_Ventana-Monorriel_Americana-SL
Type - Pset_ManufacturerTypeInformation - Manufacturer: Deceuninck
Type - Pset_ProductRequirements - Category: Windows
Type - Pset_ProvisionForVoid - Width: 1000 mm; Height: 1500 mm
Material: Vidrio, Deceuninck - 1.White/PVC
Pset_BuildingElementProxyCommon - Reference: Deceuninck_Ventana-Monorriel_Americana-SL; sets with these values: 2
Constraints - Level: Level: Level 1; Sill Height: 800 mm
Dimensions - Area: 3.61448 m2; Volume: 0.0178965 m3
Identity Data - Mark: 104
Other - Family: Deceuninck_Ventana-Monorriel_Americana-SL: Deceuninck_Ventana-Monorriel_Americana-SL; Family and Type: Deceuninck_Ventana-Monorriel_Americana-SL: Deceuninck_Ventana-Monorriel_Americana-SL; Head Height: 2300 mm; Host Id: Basic Wall: Generic - 200mm; ON_OFF - Height: no; ON_OFF - Width: no; Type: Deceuninck_Ventana-Monorriel_Americana-SL: Deceuninck_Ventana-Monorriel_Americana-SL; Type Id: Deceuninck_Ventana-Monorriel_Americana-SL: Deceuninck_Ventana-Monorriel_Americana-SL
Phasing - Phase Created: New Construction
